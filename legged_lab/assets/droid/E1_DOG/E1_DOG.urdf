Commit message: bug修改

File: legged_lab/assets/droid/E1_DOG/E1_DOG.urdf (robot description, URDF)
Before this commit: robot E1dog, 20 links, 19 joints
Joints:
- joint RL_thigh_joint: origin xyz=-0.175 0.095 0 rpy=0 0 0 -> xyz=-0.175 0.094 0 rpy=0 0 0
